# IAR project STM32F0518.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: qitas.bin
  ILINK.IlinkOutputFile: STM32F0518.out
  group (top)
    ../user/: FreeRTOSConfig.h main-blinky.c main-full.c main.c ParTest.c RegTest.s startup_stm32f0xx.s
  group Eval-Board
    ../user/Eval-Board/: stm320518_eval.c
  group FreeRTOS
    ../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    ../Source/portable/MemMang/: heap_2.c
    ../Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group Libraries/CMSIS
    ../user/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Libraries/StdPeriph_Driver
    ../user/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
  group Standard-Demo-Tasks
    ../Common/Minimal/: blocktim.c countsem.c dynamic.c recmutex.c
